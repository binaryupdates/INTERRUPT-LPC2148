# Keil uVision project INTERRUPTLPC2148.uvproj, settings and files
target INTERRUPTLPC2148 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: INTERRUPTLPC2148 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup
    ./: Startup.s
  group Source
    ./: main.c
  group Readme
    ./: readme.txt
